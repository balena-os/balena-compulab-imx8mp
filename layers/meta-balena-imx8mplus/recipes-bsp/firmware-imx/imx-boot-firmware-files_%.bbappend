FSL_EULA_FILE_MD5SUM = "bc649096ad3928ec06a8713b8d787eac"

LIC_FILES_CHKSUM_LAYER = "file://${FSL_EULA_FILE};md5=${FSL_EULA_FILE_MD5SUM}"

LIC_FILES_CHKSUM = "file://COPYING;md5=ca53281cc0caa7e320d4945a896fb837 ${LIC_FILES_CHKSUM_LAYER}"
