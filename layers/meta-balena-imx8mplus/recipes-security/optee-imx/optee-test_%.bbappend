INSANE_SKIP:${PN} += "installed-vs-shipped"
INHIBIT_PACKAGE_DEBUG_SPLIT = "1"
