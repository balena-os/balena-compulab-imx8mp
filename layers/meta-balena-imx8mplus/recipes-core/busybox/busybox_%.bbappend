FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://no-tree.cfg"
